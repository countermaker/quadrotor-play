# Keil uVision project OS3.uvprojx, settings and files
target Quad FC (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Quad FC +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,STM32F40_41xxx,ARM_MATH_CM4, __CC_ARM,__FPU_PRESENT=1,__FPU_USED
  c include: ..\BSP\KeilMDK;..\BSP\ST\STM32F4xx\inc;..\BSP\ST\STM32F4xx;..\BSP;..\APP;..\uCOS-III\uC-CPU;..\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\uCOS-III\uC-LIB;..\uCOS-III\uC-LIB\Ports;..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\uCOS-III\uCOS-III;..\uCOS-III\uCOS-III\Ports;..\uCOS-III\uCOS-III\Source;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\BSP\CMSIS\Device\ST\STM32F4xx\Include;..\BSP\CMSIS\Include;..\BSP\CMSIS\Lib\ARM;..\BSP\STM32F4xx\inc;..\BSP\STM32F4xx;..\Sensor;..\BSP\STM32_CPAL_Driver\inc;..\BSP\STM32_CPAL_Driver\devices\stm32f4xx;..\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../App/: includes.h app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h os_app_hooks.h os_app_hooks.c app.c
    ../APP/: GlobalVariable.h GlobalVariable.c StateCheckTask.c RCTask.c AttitudeTask.c ControlTask.c SerPrintTask.c ESCCalibrateTask.c AccCalibrateTask.c CommTask.c PosControlTask.c NavigateTask.c
  group BSP
    ../BSP/KeilMDK/: cstartup.s
    ../BSP/: bsp.h bsp.c bsp_int.c bsp_periph.c bsp_ser.h bsp_ser.c bsp_os.h bsp_os.c bsp_spi1.h bsp_spi1.c bsp_iic3.h bsp_iic3.c bsp_pwm.c bsp_pwm.h bsp_pwm_in.c bsp_pwm_in.h bsp_usart2.h bsp_usart2.c bsp_iic2.h bsp_iic2.c bsp_pwm2.c bsp_pwm2.h
  group Modules
    ../Modules/: algorithm.h algorithm.c sensor_update.h sensor_update.c control.c control.h motor.c motor.h rc.c rc.h cordic.c cordic.h sys_params.c sys_params.h
  group Sensor
    ../Sensor/: mpu6000.h mpu6000.c hmc5883l.h hmc5883l.c ms5611.h ms5611.c sonar.h sonar.c
  group uC/CPU
    ../ucos-iii/uC-CPU/: cpu_core.h cpu_core.c cpu_def.h
    ../ucos-iii/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../ucos-iii/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../ucos-iii/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III Port
    ../ucos-iii/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Source
    ../ucos-iii/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group STM32F4xx Library
    ../BSP/STM32F4xx/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../BSP/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
    ../BSP/STM32F4xx/: stm32f4xx_conf.h
    ../BSP/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group DSP_Lib
    ../BSP/CMSIS/DSP_Lib/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
  group STM32_CPAL_DRIVER
    ../BSP/STM32_CPAL_Driver/: cpal_usercallback.c
    ../BSP/STM32_CPAL_Driver/inc/: cpal_conf.h cpal.h cpal_i2c.h
    ../BSP/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
    ../BSP/STM32_CPAL_Driver/devices/stm32f4xx/: cpal_i2c_hal_stm32f4xx.h cpal_i2c_hal_stm32f4xx.c
